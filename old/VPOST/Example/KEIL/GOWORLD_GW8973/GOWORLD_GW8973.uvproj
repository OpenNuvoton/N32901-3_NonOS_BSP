# Keil uVision project GOWORLD_GW8973.uvproj, settings and files
target GOWORLD_GW8973_N32901 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: GOWORLD_GW8973
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCD_480x272__
  c include: ..\..\..\Lib;..\..\ASIC;..\..\..\..\SYSLIB\Lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../../Src/: main_vpost.c standalone.c wb_init.s
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../Lib/: W55FA93_VPOST_GWGW8973.lib
target GOWORLD_GW8973_N32903 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: GOWORLD_GW8973
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCD_480x272__
  c include: ..\..\..\Lib;..\..\ASIC;..\..\..\..\SYSLIB\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry Reset_Go

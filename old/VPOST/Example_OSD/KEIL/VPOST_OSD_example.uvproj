# Keil uVision project VPOST_OSD_example.uvproj, settings and files
target N32903_DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: VPOST_OSD_example
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: N32903
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\ASIC
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
  group Source Group 1
    ../Src/: main_vpost.c standalone.c W55FA93_VPOST_OSD.c wb_init.s
    ../../Lib/: W55FA93_VPOST_GPM1006D0.lib
    ../../../SYSLIB/Lib/: W55FA93_syslib.lib
target N32901_DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: VPOST_OSD_example
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: N32901
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\ASIC
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0

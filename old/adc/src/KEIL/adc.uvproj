# Keil uVision project adc.uvproj, settings and files
target ADC_INT (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA93_adc_Int (library)
  AfterMake: ADC_INT.bat
  c flags: Optim=1 wLevel=2
  c define: USING_INT
  c include: ..\..\lib;..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../: libadc.c
target ADC_POLL (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA93_adc_Poll (library)
  AfterMake: ADC_POLL.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\lib;..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000

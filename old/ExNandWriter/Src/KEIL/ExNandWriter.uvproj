# Keil uVision project ExNandWriter.uvproj, settings and files
target N32903_480x272 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: ExNandWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: ..\..\..\gnand\Lib;..\..\..\SIC\Lib;..\..\..\NVTFAT\lib;..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib;..\..\..\gpio\lib;..\..\..\Font\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
  group Source Group 1
    ../: DrawFont.c nvtNandDrv1.c ProcessIni.c standalone.c wb_init.s Writer.c
    ../../../gnand/Lib/: w55fa93_GNAND.lib
    ../../../SIC/Lib/: W55FA93_SIC.lib
    ../../../NVTFAT/lib/: W55FA93_nvtfat.lib
    ../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../gpio/lib/: w55fa93_gpio.lib
    ../../../Font/Lib/: W55FA93_font_SVGA.lib W55FA93_font_QVGA.lib W55FA93_font_WSVGA.lib
    ../../../VPOST/Lib/: W55FA93_VPOST_GPM1006D0.lib
target N32903_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: ExNandWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32903_WSVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: ExNandWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WSVGA_
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_480x272 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: ExNandWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32901_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: ExNandWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32901_WSVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: ExNandWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WSVGA_
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0

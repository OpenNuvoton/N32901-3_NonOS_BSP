# Keil uVision project dev_spi.uvproj, settings and files
target Release (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: w55fa93_SPI (library)
  AfterMake: Release.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\NVTFAT\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../: spi.c spiflash.c SPIGlue.c spiflash_freertos.c
target DebugRel_FreeRTOS (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_SPI_freertos (library)
  AfterMake: DebugRel_FreeRTOS.bat
  c flags: Optim=1 wLevel=2
  c define: __FreeRTOS__ __RAK439__
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\NVTFAT\Lib;..\..\..\FreeRTOS\Source\portable\RVDS\ARM9_N329x;..\..\..\FreeRTOS\Source\include
  memory RVCT9: RAM 0xf8002000 size 0x8000

# Keil uVision project VirtualCom.uvproj, settings and files
target N32901_VirtualCom (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: VirtualCom
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\gpio\lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
  group Source Group 1
    ../: VirtualCom.c main.c standalone.c wb_init.s demo_wakeup.c
    ../../../lib/: w55fa93_UDC.lib
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../../gpio/lib/: w55fa93_gpio.lib
target N32903_VirtaulCom (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: VirtualCom
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\gpio\lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0

# Keil uVision project RTOSDemo.uvproj, settings and files
target RTOSDemo_ARM_N32903 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: RTOSDemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: .\Startup;..\..\Source\portable\RVDS\ARM9_N329x;..\..\Source\include;..\Common\include;..\..\..\SYSLIB\Lib
  asm define: N32903
  asm include: ..\..\Source\portable\RVDS\ARM9_N329x
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
  group Startup
    ./Startup/: wb_init.s standalone.c multithread.c main.c
  group Stadard Demo
    ./Demo/: PollQ_n329.c BlockQ_n329.c semtest_n329.c dynamic_n329.c
  group Lib
    ../../../SYSLIB/Lib/: W55FA93_syslib_freertos.lib
  group FreeRTOS
    ../../Source/: tasks.c list.c queue.c
    ../../Source/portable/RVDS/ARM9_N329x/: port.c portASM.s
    ../../Source/portable/MemMang/: heap_4.c
target RTOSDemo_ARM_N32901 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: RTOSDemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  asm define: N32901
  asm include: ..\..\Source\portable\RVDS\ARM9_N329x
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0

# Keil uVision project MSC_CDROM.uvproj, settings and files
target NAND (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: w55fa93_MSC_NAND_CDROM (library)
  AfterMake: CDROM_NAND.bat
  c flags: Optim=1 wLevel=2
  c define: TEST_SM TEST_CDROM
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\gnand\Lib;..\..\..\..\SIC\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../../MSC/: mscd.c
target SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_SPI_CDROM (library)
  AfterMake: CDROM_SPI.bat
  c flags: Optim=1 wLevel=2
  c define: TEST_CDROM TEST_SPI
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SD_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_SD_PORT0_CDROM (library)
  AfterMake: CDROM_SD_PORT0.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT0 TEST_CDROM TEST_SD
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SD_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_SD_PORT1_CDROM (library)
  AfterMake: CDROM_SD_PORT1.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT1 TEST_CDROM TEST_SD
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SD_PORT2 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_SD_PORT2_CDROM (library)
  AfterMake: CDROM_SD_PORT2.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT2 TEST_CDROM TEST_SD
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SD_MultiPartition_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_SD_MP_PORT0_CDROM (library)
  AfterMake: CDROM_SD_MultiPartition_PORT0.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT0 SD_MULTIPLE_PARTITIONS TEST_CDROM TEST_SD
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SD_MultiPartition_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_SD_MP_PORT1_CDROM (library)
  AfterMake: CDROM_SD_MultiPartition_PORT1.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT1 SD_MULTIPLE_PARTITIONS TEST_CDROM TEST_SD
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SD_MultiPartition_PORT2 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_SD_MP_PORT2_CDROM (library)
  AfterMake: CDROM_SD_MultiPartition_PORT2.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT2 SD_MULTIPLE_PARTITIONS TEST_CDROM TEST_SD
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target RAM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_RAM_CDROM (library)
  AfterMake: CDROM_RAM.bat
  c flags: Optim=1 wLevel=2
  c define: TEST_CDROM TEST_RAM
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target All_Storage_SD_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_ALL_SD_PORT0_CDROM (library)
  AfterMake: CDROM_All_Storage_SD_PORT0.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT0 TEST_SM TEST_CDROM TEST_SD __ALL_STORAGE__ TEST_RAM
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target All_Storage_SD_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_ALL_SD_PORT1_CDROM (library)
  AfterMake: CDROM_All_Storage_SD_PORT1.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT1 TEST_SM TEST_CDROM TEST_SD __ALL_STORAGE__ TEST_RAM
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target All_Storage_SD_MP_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_ALL_SD_MP_PORT0_CDROM (library)
  AfterMake: CDROM_All_Storage_SD_MP_PORT0.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT0 SD_MULTIPLE_PARTITIONS TEST_SM TEST_CDROM TEST_SD __ALL_STORAGE__ TEST_RAM
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target All_Storage_SD_MP_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_ALL_SD_MP_PORT1_CDROM (library)
  AfterMake: CDROM_All_Storage_SD_MP_PORT1.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT1 SD_MULTIPLE_PARTITIONS TEST_SM TEST_CDROM TEST_SD __ALL_STORAGE__ TEST_RAM
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target CDROM_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_CDROM_Only (library)
  AfterMake: CDROM_Only.bat
  c flags: Optim=1 wLevel=2
  c define: TEST_CDROM
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000

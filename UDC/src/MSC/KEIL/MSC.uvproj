# Keil uVision project MSC.uvproj, settings and files
target NAND (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: w55fa93_MSC_NAND (library)
  AfterMake: NAND.bat
  c flags: Optim=1 wLevel=2
  c define: TEST_SM
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\gnand\Lib;..\..\..\..\SIC\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../../MSC/: mscd.c
target SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_SPI (library)
  AfterMake: SPI.bat
  c flags: Optim=1 wLevel=2
  c define: TEST_SPI SD_PORT0
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SD_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_SD_PORT0 (library)
  AfterMake: SD_PORT0.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT0 TEST_SD
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SD_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_SD_PORT1 (library)
  AfterMake: SD_PORT1.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT1 TEST_SD
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SD_PORT2 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_SD_PORT2 (library)
  AfterMake: SD_PORT2.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT2 TEST_SD
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SD_MultiPartition_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_SD_MP_PORT0 (library)
  AfterMake: SD_MultiPartition_PORT0.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT0 SD_MULTIPLE_PARTITIONS TEST_SD
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SD_MultiPartition_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_SD_MP_PORT1 (library)
  AfterMake: SD_MultiPartition_PORT1.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT1 SD_MULTIPLE_PARTITIONS TEST_SD
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SD_MultiPartition_PORT2 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_SD_MP_PORT2 (library)
  AfterMake: SD_MultiPartition_PORT2.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT2 SD_MULTIPLE_PARTITIONS TEST_SD
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target RAM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_RAM (library)
  AfterMake: RAM.bat
  c flags: Optim=1 wLevel=2
  c define: TEST_RAM
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target All_Storage_SD_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_ALL_SD_PORT0 (library)
  AfterMake: All_Storage_SD_PORT0.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT0 TEST_SM TEST_SD __ALL_STORAGE__ TEST_RAM
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target All_Storage_SD_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_ALL_SD_PORT1 (library)
  AfterMake: All_Storage_SD_PORT1.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT1 TEST_SM TEST_SD __ALL_STORAGE__ TEST_RAM
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target All_Storage_SD_MP_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_ALL_SD_MP_PORT0 (library)
  AfterMake: All_Storage_SD_MP_PORT0.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT0 SD_MULTIPLE_PARTITIONS TEST_SM TEST_SD __ALL_STORAGE__ TEST_RAM
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target All_Storage_SD_MP_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa93_MSC_ALL_SD_MP_PORT1 (library)
  AfterMake: All_Storage_SD_MP_PORT1.bat
  c flags: Optim=1 wLevel=2
  c define: SD_PORT1 SD_MULTIPLE_PARTITIONS TEST_SM TEST_SD __ALL_STORAGE__ TEST_RAM
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000

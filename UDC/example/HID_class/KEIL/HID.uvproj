# Keil uVision project HID.uvproj, settings and files
target N32901_Mouse_Keypad (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32901_Mouse_keypad
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: HID_KEYPAD HID_MOUSE
  c include: ..\..\..\lib;..\..\..\..\syslib\lib;..\..\..\..\gpio\lib;..\..\..\..\kpi\LIB;..\..\..\lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
  group Source Group 1
    ../: standalone.c HID.c main.c wb_init.s demo_wakeup.c
    ../../../lib/: w55fa93_UDC_Fullspeed.lib
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../../kpi/lib/: w55fa93_kpi_2x3.lib
    ../../../../gpio/lib/: w55fa93_gpio.lib
target N32901_Keyboard_Pattern (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_keyboard_Pattern
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: HID_KEYBOARD
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
target N32901_Mouse_Pattern (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_Mouse_Pattern
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: HID_MOUSE
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32901_Keyboard_Keypad (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_Keyboad_Keypad
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: HID_KEYPAD HID_KEYBOARD
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32903_Mouse_keypad (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_Mouse_Keypad
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: HID_MOUSE HID_KEYPAD
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32903_Mouse_Pattern (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_Mouse_Pattern
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: HID_MOUSE
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32903_Keyboard_Pattern (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_Keyboard_Pattern
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: HID_KEYBOARD
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32903_Keyboard_Keypad (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_Keyboard_Keypad
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: HID_KEYBOARD HID_KEYPAD
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0

# Keil uVision project SDWriter.uvproj, settings and files
target N32903_480x272 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_ N32903
  c include: ..\..\..\SIC\Lib;..\..\..\NVTFAT\lib;..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib;..\..\..\gpio\lib;..\..\..\Font\Lib;..\..\..\gnand\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
  group Source Group 1
    ../: DrawFont.c ProcessIni.c ProcessOptionalIni.c standalone.c wb_init.s Writer.c
    ../../../SIC/Lib/: W55FA93_SIC.lib
    ../../../NVTFAT/lib/: W55FA93_nvtfat.lib
    ../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../VPOST/Lib/: W55FA93_VPOST.lib
    ../../../gpio/lib/: w55fa93_gpio.lib
    ../../../Font/Lib/: W55FA93_font_SVGA.lib W55FA93_font_QVGA.lib W55FA93_font_WSVGA.lib
target N32903_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_ N32903
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32903_WSVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WSVGA_ N32903
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_480x272 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_ N32901
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32901_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_ N32901
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0

# Keil uVision project adc.uvproj, settings and files
target N32903_AudioRecord (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\SIC\Lib;..\..\..\gnand\Lib;..\..\..\NVTFAT\lib;..\..\..\EDMA\lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
  group Source Group 1
    ../: adc.c audioRecord.c standalone.c TouchPanel.c wb_init.s
    ../../lib/: W55FA93_adc_Int.lib W55FA93_adc_Poll.lib
    ../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../gnand/Lib/: w55fa93_GNAND.lib
    ../../../NVTFAT/lib/: W55FA93_nvtfat.lib
    ../../../SIC/Lib/: W55FA93_SIC.lib
    ../../../EDMA/lib/: w55fa93_edma.lib
target N32903_block (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32903_nonblock (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _ADC_NONBLOCK_
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32903_block_polling (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32903_nonblock_polling (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _ADC_NONBLOCK_
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32903_Touch_WakeUp (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_AudioRecord (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32901_block (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32901_nonblock (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _ADC_NONBLOCK_
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32901_block_polling (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32901_nonblock_polling (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32901_Touch_WakeUp (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0

# Keil uVision project Security.uvproj, settings and files
target N32903_DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: SpiFlash
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
  group Source Group 1
    ../../../Lib/: w55fa93_SPI.lib w55fa93_Secureic.lib
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../: standalone.c Rootkey.c Secureic.c wb_init.s
target N32901_DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiFlash
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0

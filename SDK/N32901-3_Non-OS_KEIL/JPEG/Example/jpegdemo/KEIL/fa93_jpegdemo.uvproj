# Keil uVision project fa93_jpegdemo.uvproj, settings and files
target N32903_JPEG_Demo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: fa93_jpegdemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\LIB;..\..\..\..\SYSLIB\Lib;..\..\..\..\gnand\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\VPOST\Lib;..\..\..\..\SIC\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
  group Source Group 1
    ../: standalone.c wb_init.s
    ../../: common.c jpegDec.c jpegEnc.c main.c
    ../../../LIB/: w55fa93_jpeglib.lib
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../../NVTFAT/lib/: W55FA93_nvtfat.lib
    ../../../../SIC/Lib/: W55FA93_SIC.lib
    ../../../../VPOST/Lib/: W55FA93_VPOST_GPM1006D0.lib
target N32901_JPEG_Demo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: fa93_jpegdemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0

# Keil uVision project MP3Player.uvproj, settings and files
target N32903_mp3player (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: MP3Player
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\VPOST\Lib;..\..\..\SYSLIB\Lib;..\..\..\SPU\lib;..\..\..\SIC\Lib;..\..\..\NVTFAT\lib;..\..\..\JPEG\LIB;..\..\..\gnand\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32903\N32903.sct
  link misc: --entry 0
  group Source Group 1
    ../: Demo_MP3.c standalone.c wb_init.s
    ../../Lib/: AviLib_320x240.lib ima_adpcm_codec.lib mp3lib.lib
    ../../../VPOST/Lib/: W55FA93_VPOST.lib
    ../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../SPU/lib/: w55fa93_spu.lib
    ../../../SIC/Lib/: W55FA93_SIC.lib
    ../../../NVTFAT/lib/: W55FA93_nvtfat.lib
    ../../../JPEG/LIB/: w55fa93_jpeglib.lib
    ../../../gnand/Lib/: w55fa93_GNAND.lib
target N32901_mp3player (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: MP3Player
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32901\N32901.sct
  link misc: --entry 0

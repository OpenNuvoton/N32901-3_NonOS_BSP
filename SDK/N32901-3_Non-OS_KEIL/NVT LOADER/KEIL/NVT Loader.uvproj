# Keil uVision project NVT Loader.uvproj, settings and files
target N32903_NAND_GPM1006D0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32903_NVT_NAND_GPM1006D0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: N32903 __GWMT9360A__ __LCM_QVGA__
  c include: ..\inc;..\..\AVI\Lib;..\..\VPOST\Lib;..\..\adc\lib;..\..\RTC\LIB;..\..\Font\Lib;..\..\gnand\Lib;..\..\gpio\lib;..\..\JPEG\LIB;..\..\kpi\lib;..\..\UDC\lib;..\..\NVTFAT\lib;..\..\SIC\Lib;..\..\SPU\lib;..\..\SYSLIB\Lib;..\..\USB_Core\lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT Loader\src\scat.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ../../NVT Loader/src/: avi.c heap.s main.c mass.c stack.s standalone.c vectors.s wb_init.s
    ../../AVI/Lib/: AviLib_320x240.lib ima_adpcm_codec.lib mp3lib.lib
    ../../gnand/Lib/: w55fa93_GNAND.lib
    ../../gpio/lib/: w55fa93_gpio.lib
    ../../JPEG/LIB/: w55fa93_jpeglib.lib
    ../../kpi/lib/: w55fa93_kpi_2x3.lib
    ../../UDC/lib/: w55fa93_MSC_NAND.lib w55fa93_MSC_SD_MP_PORT0.lib w55fa93_UDC.lib
    ../../NVTFAT/lib/: W55FA93_nvtfat.lib
    ../../SIC/Lib/: W55FA93_SIC.lib
    ../../SPU/lib/: w55fa93_spu.lib
    ../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../VPOST/Lib/: W55FA93_VPOST_GPM1006D0.lib
target N32903_SD_GPM1006D0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_NVT_SDU0_GPM1006D0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD2_DEMO__ N32903 __GWMT9360A__ __LCM_QVGA__ __ENABLE_SD_CARD_0__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\NVT Loader\src\scat.scf
  link misc: --entry Reset_Go
target N32901_NAND_GPM1006D0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_NVT_NAND_GPM1006D0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __GWMT9360A__ __LCM_QVGA__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32901_SD_GPM1006D0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_NVT_SDU0_GPM1006D0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __GWMT9360A__ __LCM_QVGA__ __ENABLE_SD_CARD_0__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\src\scat_N32901.scf
  link misc: --entry Reset_Go

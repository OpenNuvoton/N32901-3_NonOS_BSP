# Keil uVision project demo.uvproj, settings and files
target N32903_Demo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Lib;..\..\..\..\VPOST\Lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\SPI\Lib;..\..\..\..\VPOST\Example\ASIC
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
  group Source Group 1
    ../../: main.c Smpl_Pdma_SPI.c Smpl_Pdma_UART.c Smpl_Vdma.c standalone.c wb_init.s
    ../../../lib/: w55fa93_edma.lib
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../../VPOST/Lib/: W55FA93_VPOST.lib
    ../../../../SPI/Lib/: w55fa93_SPI.lib
target N32901_Demo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0

# Keil uVision project SpiLoader_Security_gzip.uvproj, settings and files
target N32903_GPM1006D0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: SpiLoader_Security_gzip_GPM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: _N32903_ __LCM_QVGA__ CONFIG_BZIP2 __Security__
  c include: ..\..\SpiLoader_gzip\inc;..\..\..\..\VPOST\Lib;..\..\..\..\gpio\lib;..\..\..\..\JPEG\LIB;..\..\..\..\kpi\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\SPU\lib;..\..\..\..\AVI\Lib;..\..\SpiLoader_gzip\src\ziplib;..\..\..\..\SPI\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ../../SpiLoader_gzip/src/: cmd_bootm.c heap.s main.c SpiRead.c stack.s standalone.c vectors.s wb_init.s
    ../../../../gpio/lib/: w55fa93_gpio.lib
    ../../../../JPEG/LIB/: w55fa93_jpeglib.lib
    ../../../../kpi/lib/: w55fa93_kpi.lib
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../../SPU/lib/: w55fa93_spu.lib
    ../../SpiLoader_gzip/src/ziplib/: zlib.c
    ../../../../VPOST/Lib/: W55FA93_VPOST_GPM1006D0.lib
    ../src/: Rootkey.c
    ../../../../SPI/Lib/: w55fa93_Secureic.lib
target N32903_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_Security_gzip
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: _N32903_ __No_LCM__ CONFIG_BZIP2 __Security__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader_gzip\src\scat.scf
  link misc: --entry Reset_Go
target N32901_GPM1006D0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_Security_gzip_GPM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: _N32901_ __LCM_QVGA__ CONFIG_BZIP2 __Security__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32901_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader_Security_gzip
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: _N32901_ __No_LCM__ CONFIG_BZIP2 __Security__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\src\scat_N32901.scf
  link misc: --entry Reset_Go

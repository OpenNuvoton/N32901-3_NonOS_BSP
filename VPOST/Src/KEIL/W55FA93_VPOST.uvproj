# Keil uVision project W55FA93_VPOST.uvproj, settings and files
target GIANTPLUS (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA93_VPOST_GPM1006D0 (library)
  AfterMake: GIANTPLUS.bat
  c flags: Optim=3 wLevel=2
  c define: GIANTPLUS
  c include: ..\..\lib;..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../: W55FA93_VPOST.C W55FA93_VPOST_AMPIRE_800x480.c W55FA93_VPOST_AMPIRE_800x600.c W55FA93_VPOST_Driver.c W55FA93_VPOST_GIANTPLUS_GPM1006D0.c W55FA93_VPOST_GOWORLD_GW07000TNWV.c W55FA93_VPOST_GOWORLD_GW8973.c W55FA93_VPOST_GOWORLD_GWMTF9360A.c W55FA93_VPOST_GOWORLD_GWMTF9360A_modify.c W55FA93_VPOST_GOWORLD_GWMTF9406A.c W55FA93_VPOST_GOWORLD_GWMTF9615A.c W55FA93_VPOST_HANNSTAR_HSD043I9W1.c W55FA93_VPOST_HANNSTAR_HSD070IDW1.c W55FA93_VPOST_HIMAX_HX8346.c W55FA93_VPOST_RISETECH_OTA5182A.c W55FA93_VPOST_RISETECH_OTA5182A_CCIR656.c W55FA93_VPOST_SHARP_LQ035Q1DH02.c W55FA93_VPOST_SITRONIX_ST7567.c W55FA93_VPOST_TECHTRON_R61505V.c W55FA93_VPOST_TIANMA_TM022HDH31.c W55FA93_VPOST_TOPPOLY_TD028THEA1.c W55FA93_VPOST_TVOUT_D1_720x480.c W55FA93_VPOST_TVOUT_QVGA_320x240.c W55FA93_VPOST_TVOUT_VGA_640x480.c W55FA93_VPOST_VG680.c W55FA93_VPOST_WINTEK_WMF3324_320x240.c

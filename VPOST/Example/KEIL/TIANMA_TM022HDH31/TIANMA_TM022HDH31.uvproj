# Keil uVision project TIANMA_TM022HDH31.uvproj, settings and files
target TIANMA_TM022HDH31_N32901 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: TIANMA_TM022HDH31
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCD_320x240__
  c include: ..\..\..\Lib;..\..\ASIC;..\..\..\..\SYSLIB\Lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../../Src/: main_vpost.c standalone.c wb_init.s
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../Lib/: W55FA93_VPOST_TIANMA_TM022HDH31.lib
target TIANMA_TM022HDH31_N32903 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: TIANMA_TM022HDH31
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCD_320x240__
  c include: ..\..\..\Lib;..\..\ASIC;..\..\..\..\SYSLIB\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry Reset_Go

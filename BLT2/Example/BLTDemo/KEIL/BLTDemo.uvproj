# Keil uVision project BLTDemo.uvproj, settings and files
target N32903_DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: BLTDemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\VPOST\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
  group Source Group 1
    ../: main.c standalone.c wb_init.s
    ../../../Lib/: W55FA93_blt.lib
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../../VPOST/Lib/: W55FA93_VPOST_GPM1006D0.lib
target N32901_DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: BLTDemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\VPOST\Lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0

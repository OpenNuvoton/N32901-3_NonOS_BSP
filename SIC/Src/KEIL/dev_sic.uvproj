# Keil uVision project dev_sic.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA93_SIC (library)
  AfterMake: DebugRel.bat
  c flags: Optim=1 wLevel=2
  c define: __SD0_NO_CARD_DETECT
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\gnand\Lib;..\..\..\NVTFAT\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../: fmi.c NandDrv.c sd.c SDGlue.c sic.c

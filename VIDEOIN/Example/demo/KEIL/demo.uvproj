# Keil uVision project demo.uvproj, settings and files
target N32903_3drB_GiantPlus (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __3RD_PORT__ __DEMO_BOARD__
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\gpio\lib;..\..\..\..\SIC\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\VPOST\Lib;..\..\..\..\gnand\Lib;..\..\I2CS
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
  group Source Group 1
    ../../: demo.c GCD.c Smpl_FSC_NT99050.c Smpl_FSC_NT99140.c Smpl_FSC_NT99141.c Smpl_FSC_Ov7670.c Smpl_FSC_Ov7725.c Smpl_FSC_Ov9660.c Smpl_I2C.c Smpl_VPOST.c Smpl_WT8861.c standalone.c wb_init.s Smpl_FSC_GC0308.c Smpl_FSC_TW9900.c Smpl_FSC_GM7150.c Smpl_FSC_TVP5150.c
    ../../../Lib/: W55FA93_VideoIn.lib
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../../gpio/lib/: w55fa93_gpio.lib
    ../../../../SIC/Lib/: W55FA93_SIC.lib
    ../../../../NVTFAT/lib/: W55FA93_nvtfat.lib
    ../../I2CS/: DrvI2C.c
    ../../../../VPOST/Lib/: W55FA93_VPOST_GPM1006D0.lib
target N32903_2ndP_GW9360 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __2ND_PORT__ __DEMO_BOARD__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_3rdB_GiantPlus (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __3RD_PORT__ __DEMO_BOARD__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32901_2ndP_GW9360 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __2ND_PORT__ __DEMO_BOARD__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32903_2ndP_NuWiCam (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __2ND_PORT__ __NUWICAM__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_2ndP_NuWiCam (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __2ND_PORT__ __NUWICAM__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
target N32903_HMI_GiantPlus (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __1ST_PORT__ __HMI_BOARD__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
target N32901_HMI_GiantPlus (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __1ST_PORT__ __HMI_BOARD__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0

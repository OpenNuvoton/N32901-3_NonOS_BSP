# Keil uVision project demo.uvproj, settings and files
target N32903_SingleTask (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\VideoIn\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  group Source Group 1
    ../: main.c standalone.c wb_init.s
    ../../../lib/: w55fa93_i2c.lib
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../../VideoIn/Lib/: W55FA93_VideoIn.lib
target N32901_SingleTask (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\VideoIn\Lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct

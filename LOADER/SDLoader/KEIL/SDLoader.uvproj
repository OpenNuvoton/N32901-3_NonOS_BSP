# Keil uVision project SDLoader.uvproj, settings and files
target N32903_SDLoader_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32903_SDLoader_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SDLoader\SdLoader.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ../../SDLoader/: Depop.c heap.s sd.c SdLoader.c stack.s standalone.c vectors.s wb_config.c wb_init.s wb_uart.c
target M32903_SDLoader_S605_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_SDLoader_S605_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __UPLL_192__ _S605_
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SDLoader\SdLoader.scf
  link misc: --entry Reset_Go
target N32901_SDLoader_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_SDLoader_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader_N32901.scf
  link misc: --entry Reset_Go
target N32901_SDLoader_S605_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_SDLoader_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __UPLL_192__ _S605_
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader_N32901.scf
  link misc: --entry Reset_Go

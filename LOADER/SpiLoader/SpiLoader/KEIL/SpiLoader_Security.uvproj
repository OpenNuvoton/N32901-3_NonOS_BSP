# Keil uVision project SpiLoader_Security.uvproj, settings and files
target N32903_GPM1006D0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N32903_SpiLoader_Security_GPM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __GWMT9360A__ __LCM_QVGA__ __Security__
  c include: ..\inc;..\..\..\..\VPOST\Lib;..\..\..\..\gpio\lib;..\..\..\..\JPEG\LIB;..\..\..\..\kpi\lib;..\..\..\..\SPU\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\AVI\Lib;..\..\..\..\SPI\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ../../SpiLoader/src/: heap.s main.c SpiRead.c stack.s standalone.c vectors.s wb_init.s
    ../../../../gpio/lib/: w55fa93_gpio.lib
    ../../../../JPEG/LIB/: w55fa93_jpeglib.lib
    ../../../../kpi/lib/: w55fa93_kpi.lib
    ../../../../SPU/lib/: w55fa93_spu.lib
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../../VPOST/Lib/: W55FA93_VPOST_GPM1006D0.lib
    ../../../../SPI/Lib/: w55fa93_Secureic.lib
    ../src/: Rootkey.c
target N32903_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32903_SpiLoader_Security_NoLCM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __No_LCM__ __Security__
  c include: as above
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\SpiLoader\src\scat.scf
  link misc: --entry Reset_Go
target N32901_GPM1006D0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_SpiLoader_Security_GPM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __GWMT9360A__ __LCM_QVGA__ __Security__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\src\scat_N32901.scf
  link misc: --entry Reset_Go
target N32901_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N32901_SpiLoader_Security_NoLCM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 wLevel=2
  c define: __No_LCM__ __Security__
  c include: as above
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\src\scat_N32901.scf
  link misc: --entry Reset_Go

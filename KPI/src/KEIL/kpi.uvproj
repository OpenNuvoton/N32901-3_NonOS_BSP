# Keil uVision project kpi.uvproj, settings and files
target Release (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: w55fa93_kpi (library)
  AfterMake: Release.bat
  c flags: Optim=3 wLevel=2
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\gpio\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../: libkpi.c

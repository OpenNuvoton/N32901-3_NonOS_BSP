# Keil uVision project blt_sample.uvproj, settings and files
target DebugRel_N32901 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: blt_sample
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Lib;..\..\..\..\VPOST\Lib;..\..\..\..\SYSLIB\Lib
  asm define: N32901
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32901\N32901.sct
  link misc: --entry 0
  group Source Group 1
    ../../: BlitAlpha.c BlitOp.c CommFunc.c FI.c FillOp.c main.c standalone.c wb_init.s
    ../../../lib/: bitblt.lib
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../../VPOST/Lib/: W55FA93_VPOST.lib
target DebugRel_N32903 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: blt_sample
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Lib;..\..\..\..\VPOST\Lib;..\..\..\..\SYSLIB\Lib
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32903\N32903.sct
  link misc: --entry 0
